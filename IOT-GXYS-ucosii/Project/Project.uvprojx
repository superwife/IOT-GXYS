# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: STM32F0XX,USE_STDPERIPH_DRIVER
  c include: ..\User;..\uCOS-II\Ports;..\uCOS-II\Source;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\STM32F0xx_CPAL_Driver\inc;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\User\driver;.\Libraries\STM32F0xx_StdPeriph_Driver\src;..\User\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../User/: main.c stm32f0xx_it.c
    ../User/driver/: spi_flash.c
    ../User/app/: gprs_protocol_app.c ptu_app.c nfc_app.c
  group driver
    ../User/app/: sec_app.c
    ../User/driver/: led_app.c usart.c spi_175xx.c fm175xx.c wtn6170.c w25qxx.c motor_ctrl.c usart_4g.c
  group StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c
  group Startup
    ./: startup_stm32f0xx.s
  group CMSIS
    ../User/: system_stm32f0xx.c
  group uCOS-II Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uSOS-II Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
